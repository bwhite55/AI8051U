# Keil uVision project ai8051.uvproj, settings and files
target ai8051u (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ai8051 +hex
  group Application
    ./: ai8051u_conf.h main.c
  group Drivers
    ./Drivers/src/: hsspi.c i2c.c spi.c uart.c usart.c
    ./Drivers/inc/: hsspi.h i2c.h spi.h uart.h usart.h
